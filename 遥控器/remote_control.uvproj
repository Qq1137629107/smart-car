# Keil uVision project remote_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: remote_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Qiao
    ./: main.c nrf24l01.c lcd12864.c adc.c public.h font.h eeprom.c initall.c menu.c key _scan.c
