# Keil uVision project adc_test2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: adc_test2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c adc_driver.c commom.h oled.c iic.c font.h
