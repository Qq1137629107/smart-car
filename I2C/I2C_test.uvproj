# Keil uVision project I2C_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: I2C_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 mian.c
  group Drivers
    ./: I2C.c I2C.h SMG.c SMG.h KEY.c KEY.h AT24C02.c AT24C02.h
  group public
    ./: public.c public.h
