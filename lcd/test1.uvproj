# Keil uVision project test1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: test1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group drivers
    ./: drivers.h lcd.c drivers.c font.h
