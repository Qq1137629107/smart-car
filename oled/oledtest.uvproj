# Keil uVision project oledtest.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: oledtest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group oled
    ./: oled.c oled.h oledfont.h cmd_data.h bmp.h
  group public
    ./: public.h public.c
