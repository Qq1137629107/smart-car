# Keil uVision project transmitter.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: transmitter +hex
  c flags: Optimize=8 SizeSpeed=1
  group Qiao
    ./: main.c commom.h nrf24l01.c iic.c oled.c font.h
