# Keil uVision project remote_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: remote_control
  c flags: Optimize=8 SizeSpeed=1
  group Qiao
    ./: main.c commom.h lcd12864.c nrf24l01.c adc.c font.h init.c menu.c menu1.c menu2.c menu3.c key.c eeprom.c
