# Keil uVision project 第三期.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: 第三期 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group oled
    ./: oled.h oledfont.h cmd_data.h oled.c
  group public
    ./: public.c public.h
  group menu
    ./: menu.c menu.h
  group iic
    ./: iic.c iic.h
  group smg
    ./: smg.c smg.h
  group beepled
    ./: beepled.c beepled.h
