# Keil uVision project receiver.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: receiver +hex
  c flags: Optimize=8 SizeSpeed=1
  group Qiao
    ./: main.c commom.h nrf24l01.c oled.c font.h
